# IAR project ei-shhx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207xx ST STM32F207xx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; RT_USING_IDE_IAR
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\base_kernel\include; ..\..\src; ..\..\src\applications; ..\..\src\Drivers; ..\..\base_kernel\components\CMSIS\Include; ..\..\base_kernel\components\drivers\include; ..\.; ..\..\base_kernel\components\drivers\spi\sfud\inc; ..\..\base_kernel\libcpu\arm\cortex-m3; ..\..\base_kernel\libcpu\arm\common; ..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\base_kernel\components\drivers\spi; ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; ..\..\base_kernel\components\finsh; ..\..\cm_backtrace
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ei-shhx.bin
  ILINK.IlinkOutputFile: ei-shhx.out
  ILINK.IlinkIcfFile: E:\workStation\SVN\shhx\project\iar\STM32F2xx.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Applications
    ../../src/applications/: application.c canapp.c main.c user_finsh_cmd.c version.c
    ../../base_kernel/examples/pm/: timer_app.c
  group cm_backtrace
    ../../cm_backtrace/: cm_backtrace.c
  group Cortex-m3
    ../../base_kernel/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../base_kernel/libcpu/arm/cortex-m3/: context_iar.S cpuport.c
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group DeviceDrivers
    ../../base_kernel/components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c waitqueue.c workqueue.c
  group DeviceDrivers/Can
    ../../base_kernel/components/drivers/can/: can.c
  group DeviceDrivers/Gpio
    ../../base_kernel/components/drivers/misc/: pin.c
  group DeviceDrivers/Pm
    ../../base_kernel/components/drivers/pm/: pm.c
  group DeviceDrivers/Serial
    ../../base_kernel/components/drivers/serial/: serial.c
  group DeviceDrivers/Spi
    ../../base_kernel/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../base_kernel/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
  group Drivers
    ../../src/Drivers/: board.c
    ../../src/: stm32f2xx_it.c
  group Drivers/Can
    ../../src/Drivers/: bxcan.c
  group Drivers/Gpio
    ../../src/Drivers/: gpio.c
  group Drivers/Modem
    ../../src/Drivers/: ec20.c
  group Drivers/Serial
    ../../src/Drivers/: usart.c
  group Drivers/Spi
    ../../src/Drivers/: spi_master.c
  group finsh
    ../../base_kernel/components/finsh/: cmd.c finsh.h finsh_api.h finsh_compiler.c finsh_error.c finsh_error.h finsh_heap.c finsh_heap.h finsh_init.c finsh_node.c finsh_node.h finsh_ops.c finsh_ops.h finsh_parser.c finsh_parser.h finsh_token.c finsh_token.h finsh_var.c finsh_var.h finsh_vm.c finsh_vm.h msh.c msh.h msh_cmd.c msh_file.c shell.c shell.h symbol.c
  group Kernel
    ../../base_kernel/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c module.h object.c scheduler.c signal.c slab.c thread.c timer.c
  group STM32_StdPeriph
    ../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/iar/: startup_stm32f2xx.s
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
