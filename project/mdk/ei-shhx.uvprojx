# Keil uVision project ei-shhx.uvprojx, settings and files
target project (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F207VCTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ei-shhx +hex
  AfterMake: d:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ./Bin/ei-shhx.bin ./Objects/ei-shhx.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\project;..\..\src;..\..\src\applications;..\..\src\Drivers;..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;..\..\base_kernel\components\CMSIS\Include;..\..\base_kernel\include;..\..\base_kernel\libcpu\arm\cortex-m3;..\..\base_kernel\libcpu\arm\common;..\..\base_kernel\components\drivers\include;..\..\base_kernel\components\drivers\spi;..\..\base_kernel\components\drivers\spi\sfud\inc;..\..\base_kernel\components\finsh
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    ../../src/applications/: application.c canapp.c main.c user_finsh_cmd.c version.c
  group STM32_StdPeriph
    ../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/arm/: startup_stm32f2xx.s
  group Cortex-m3
    ../../base_kernel/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../base_kernel/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Kernel
    ../../base_kernel/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group DeviceDrivers
    ../../base_kernel/components/drivers/can/: can.c
    ../../base_kernel/components/drivers/misc/: pin.c
    ../../base_kernel/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../base_kernel/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    ../../base_kernel/components/drivers/src/: completion.c dataqueue.c pipe.c waitqueue.c workqueue.c ringbuffer.c
    ../../base_kernel/components/drivers/serial/: serial.c
  group Drivers
    ../../src/Drivers/: board.c bxcan.c drv_rtc.c gpio.c spi_master.c usart.c ec20.c
    ../../src/: stm32f2xx_it.c
  group finsh
    ../../base_kernel/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
